# Keil uVision project VK-7201A.uvproj, settings and files
target VK-7201A (MCS-51)
  device: CMS80F731x Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(48000000) MODDP2
  output: VK-7201A +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\CORE;..\FWLib\inc;..\SYSTEM;..\USER\app;..\TOUCHLib;..\USER\driver;..\USER\event;..\USER\mid
  link misc: REMOVEUNUSED
  group CORE
    ../CORE/: cms80f731xx.h STARTUP_CMS80F731x.A51
  group FWLib
    ../FWLib/src/: adc.c flash.c gpio.c system.c timer.c wdt.c led.c buzzer.c crc.c extint.c i2c.c lse.c pwm.c spi.c uart.c wut.c
  group TOUCHLib
    ../TOUCHLib/: CheckTouchKey_Set.h CheckTouchKey_Set.c REL_Protocol.h REL_Protocol.c CheckTouchKey_80F73xx.h CheckTouchKey_80F73xx_EMC_V1.01.LIB
  group SYSTEM
    ../SYSTEM/: systime.c
  group USER
    ../USER/app/: main.c
    ../USER/driver/: debug.c Eeprom.c GetADC.c heater.c led_drv.c NTC.c scan_key.c buzzer_drv.c
    ../USER/event/: Common.c emergency.c Idle.c init.c Work.c
    ../USER/mid/: station.c subprog.c
  group README
    ../: README.txt
